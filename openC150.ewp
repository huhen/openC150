# IAR project openC150.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207RB STM8S207RB
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207; F_CPU=16000000; DEBUG; USE_FULL_ASSERT
  ICCSTM8.CCIncludePath2: src; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: openC150.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG; STM8S207; F_CPU=16000000; RELEASE
  OBJCOPY.OOCOutputFile: openC150.hex
  ILINK.IlinkOutputFile: openC150.out
  group src
    src/: charger.c charger.h errors.c errors.h hardware.h lcd.c lcd.h main.c prog_ef.c prog_ef.h prog_li.c prog_li.h prog_lm.c prog_lm.h prog_ni.c prog_ni.h prog_pb.c prog_pb.h prog_us.c prog_us.h stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S_StdPeriph_Driver/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc2.h stm8s_awu.h stm8s_beep.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim3.h stm8s_tim4.h stm8s_uart1.h stm8s_uart3.h stm8s_wwdg.h
  group STM8S_StdPeriph_Driver/src
    STM8S_StdPeriph_Driver/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
